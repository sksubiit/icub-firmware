# Keil uVision project stm32hal.g4.uvprojx, settings and files
target stm32g4eval-v111 (6180000::V6.18::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32hal_stm32g4eval_v111 (library)
  AfterMake: cmd.exe /C copy .\g4-obj\stm32hal_stm32g4eval_v111.lib ..\lib\stm32hal.g4.stm32g4eval.v111.lib
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STM32G4EVAL STM32HAL_DRIVER_V111 STM32G474xx
  c include: ..\api;..\src\driver\stm32g4-v111\inc;..\src\board\stm32g4eval\v111\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group stm32hal
    ../src/stm32hal/: stm32hal.c
  group driver-stm32g4-hal-v111
    ../src/driver/stm32g4-v111/src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_irda.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_lptim.c stm32g4xx_hal_nand.c stm32g4xx_hal_nor.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c system_stm32g4xx.c
  group driver-stm32g4-ll-v111
    ../src/driver/stm32g4-v111/src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_fmc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_usb.c stm32g4xx_ll_utils.c
  group board-stm32g4eval-v111
    ../src/board/stm32g4eval/v111/src/: board_stm32g4eval_v111.c adc.c comp.c dac.c fdcan.c fmac.c fmc.c gpio.c hrtim.c i2c.c rng.c spi.c stm32g4xx_hal_msp.c tim.c usart.c usb.c dma.c
  group board-pmc-v111
    ../src/board/pmc/v111/src/: board_pmc_v111.c adc.c comp.c cordic.c crc.c dma.c fdcan.c fmac.c gpio.c i2c.c rng.c rtc.c spi.c stm32g4xx_hal_msp.c tim.c usb.c
  group board-pmc-v120
    ../src/board/pmc/v120/src/: board_pmc_v120.c adc.c comp.c cordic.c crc.c dma.c fdcan.c fmac.c gpio.c i2c.c rng.c rtc.c spi.c stm32g4xx_hal_msp.c tim.c usb.c
  group driver-stm32g4-hal-v120
    ../src/driver/stm32g4-v120/src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_irda.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_lptim.c stm32g4xx_hal_nand.c stm32g4xx_hal_nor.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c system_stm32g4xx.c
  group driver-stm32g4-ll-v120
    ../src/driver/stm32g4-v120/src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_fmc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_usb.c stm32g4xx_ll_utils.c
  group board-stm32g4eval-v120
    ../src/board/stm32g4eval/v120/src/: board_stm32g4eval_v120.c adc.c comp.c dac.c dma.c fdcan.c fmac.c fmc.c gpio.c hrtim.c i2c.c rng.c spi.c stm32g4xx_hal_msp.c tim.c usart.c usb.c
  group board-amcbldc-v120
    ../src/board/amcbldc/v120/src/: board_amcbldc_v120.c adc.c cordic.c crc.c dma.c fdcan.c fmac.c gpio.c i2c.c rng.c tim.c usb.c stm32g4xx_hal_msp.c
  group board-amcbldc-v122
    ../src/board/amcbldc/v122/src/: board_amcbldc_v122.c adc.c cordic.c crc.c dma.c fdcan.c fmac.c gpio.c i2c.c rng.c stm32g4xx_hal_msp.c tim.c usb.c
  group driver-stm32g4-hal-v122
    ../src/driver/stm32g4-v122/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_irda.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_lptim.c stm32g4xx_hal_nand.c stm32g4xx_hal_nor.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_smbus_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c system_stm32g4xx.c
  group driver-stm32g4-ll-v122
    ../src/driver/stm32g4-v122/Src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_fmc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_usb.c stm32g4xx_ll_utils.c
target pmc-v111 (6180000::V6.18::ARMCLANG)
  device: STM32G474VEHx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: stm32hal_pmc_v111 (library)
  AfterMake: cmd.exe /C copy .\g4-obj\stm32hal_pmc_v111.lib ..\lib\stm32hal.g4.pmc.v111.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_PMC STM32HAL_DRIVER_V111 STM32G474xx
  c include: ..\api;..\src\driver\stm32g4-v111\inc;..\src\board\pmc\v111\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target pmc-v120 (6180000::V6.18::ARMCLANG)
  device: STM32G474VEHx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: stm32hal_pmc_v120 (library)
  AfterMake: cmd.exe /C copy .\g4-obj\stm32hal_pmc_v120.lib ..\lib\stm32hal.g4.pmc.v120.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_PMC STM32HAL_DRIVER_V120 STM32G474xx
  c include: ..\api;..\src\driver\stm32g4-v120\inc;..\src\board\pmc\v120\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target stm32g4eval-v120 (6240000::V6.24::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: stm32hal_stm32g4eval_v120 (library)
  AfterMake: cmd.exe /C copy .\g4-obj\stm32hal_stm32g4eval_v120.lib ..\lib\stm32hal.g4.stm32g4eval.v120.lib
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STM32G4EVAL STM32HAL_DRIVER_V120 STM32G474xx
  c include: ..\api;..\src\driver\stm32g4-v120\inc;..\src\board\stm32g4eval\v120\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target amcbldc-v120 (6190000::V6.19::ARMCLANG)
  device: STM32G474VEHx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: stm32hal_amcbldc_v120 (library)
  AfterMake: cmd.exe /C copy .\g4-obj\stm32hal_amcbldc_v120.lib ..\lib\stm32hal.g4.v120.amcbldc.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V120 STM32G474xx
  c include: ..\api;..\src\driver\stm32g4-v120\inc;..\src\board\amcbldc\v120\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target amcbldc-v122 (6240000::V6.24::ARMCLANG)
  device: STM32G474CCUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32hal_amcbldc_v122 (library)
  AfterMake: cmd.exe /C copy .\g4-obj\stm32hal_amcbldc_v122.lib ..\lib\stm32hal.g4.v122.amcbldc.lib
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_AMCBLDC STM32HAL_DRIVER_V122 STM32G474xx
  c include: ..\api;..\src\driver\stm32g4-v122\inc;..\src\board\amcbldc\v122\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
