# Keil uVision project stm32g4eval-application02.uvprojx, settings and files
target stm32g4eval-app02 (6220000::V6.22::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32g4eval +hex
  AfterMake: cmd.exe /C copy .\Obj\stm32g4eval.hex ..\bin\stm32g4eval.hex
  c flags: Optim=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STM32G4EVAL STM32HAL_DRIVER_V120
  c misc: -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\..\eBcode\arch-arm\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\eBcode\arch-arm\libs\midware\eventviewer\api;..\..\..\..\..\..\eBcode\arch-arm\embobj\core\exec\multitask-;..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core-;..\..\..\..\..\..\eBcode\arch-arm\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\eBcode\arch-arm\embot\app;..\..\..\..\..\..\eBcode\arch-arm\embot\i2h;..\..\..\..\..\..\eBcode\arch-arm\embot\hw;..\..\..\..\..\..\eBcode\arch-arm\embot\os;..\..\..\..\..\..\eBcode\arch-arm\embot;..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\embot\app\dsp;..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\embot\app\skeleton;..\..\..\..\embot\prot\can;..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32g4eval-application.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: stm32g4eval-main02.cpp tCOMM.cpp tSNSR.cpp tCTRL.cpp
    ../../../../embot/app/: embot_app_PZdriver.cpp embot_app_application_theFAPreader.cpp
    ../../../../embot/app/skeleton/: embot_app_skeleton_os_basic.cpp embot_app_skeleton_os_evthreadcan.cpp
  group stm32hal
    ../../../../libs/lowlevel/stm32hal/lib/: stm32hal.g4.stm32g4eval.v120.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.stm32g4eval.s
  group rtos
    ../../../../../../eBcode/arch-arm/libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../../eBcode/arch-arm/libs/midware/eventviewer/src/: eventviewer.c
    ../../../../libs/highlevel/abslayer/cmsisos2/lib/: cmsisos2.lib
  group embot
    ../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp
    ../../../../../../eBcode/arch-arm/embot/os/: embot_os.cpp embot_os_Thread.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Timer.cpp
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theJumper.cpp
    ../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
    ../../../../../../eBcode/arch-arm/embot/app/dsp/: embot_dsp.cpp
    ../../../../embot/app/: embot_app_theLEDmanager.cpp
    ../../../../embot/os/: embot_os_Action.cpp embot_os_rtos.cpp
  group embot-protocol
    ../../../../../../eBcode/arch-arm/embot/prot/can/: embot_prot_can.cpp embot_prot_can_skin_periodic.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_bootloader.cpp embot_prot_can_analog_polling.cpp embot_prot_can_analog_periodic.cpp
  group embot-parser
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_application_theCANparserBasic.cpp embot_app_application_theCANparserIMU.cpp
    ../../../../embot/app/: embot_app_application_theCANparserPOS.cpp
  group embot-application
    ../../../../../../eBcode/arch-arm/embot/app/: embot_app_theApplication.cpp embot_app_theCANboardInfo.cpp embot_app_application_theCANtracer.cpp embot_app_application_theIMU.cpp
    ../../../../embot/app/: embot_app_theStorage.cpp
  group embot-hw
    ../../../../../../eBcode/arch-arm/embot/hw/: embot_hw.cpp embot_hw_sys.cpp embot_hw_bsp.cpp embot_hw_FlashStorage.cpp embot_hw_FlashBurner.cpp embot_hw_can.cpp embot_hw_flash.cpp embot_hw_timer.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_button.cpp
    ../../../../embot/hw/: embot_hw_i2c.cpp embot_hw_tlv493d.cpp
  group embot-hw-lowlevel
    ../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::hw::bsp
    ../../bsp/: embot_hw_bsp_stm32g4eval.cpp embot_hw_bsp_DRIVER_stm32g4eval.cpp embot_hw_button_bsp_stm32g4eval.cpp embot_hw_can_bsp_stm32g4eval.cpp embot_hw_flash_bsp_stm32g4eval.cpp embot_hw_gpio_bsp_stm32g4eval.cpp embot_hw_i2c_bsp_stm32g4eval.cpp embot_hw_i2ce_bsp_stm32g4eval.cpp embot_hw_led_bsp_stm32g4eval.cpp embot_hw_specialize_bsp_stm32g4eval.cpp embot_hw_tlv493d_bsp_stm32g4eval.cpp
target stm32g4eval-app02-ulpro (6220000::V6.22::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: stm32g4eval +hex
  AfterMake: cmd.exe /C copy .\Obj\stm32g4eval.hex ..\bin\stm32g4eval.hex
  c flags: Optim=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STM32G4EVAL STM32HAL_DRIVER_V120
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32g4eval-application.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
