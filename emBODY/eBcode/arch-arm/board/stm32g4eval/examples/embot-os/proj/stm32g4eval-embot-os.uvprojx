# Keil uVision project stm32g4eval-embot-os.uvprojx, settings and files
target stm32g4eval (6220000::V6.22::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: g4eval +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STM32G4EVAL STM32HAL_DRIVER_V120
  c misc: -Wno-pragma-pack -Wno-deprecated-register
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group main
    ../src/: main-embot-os.cpp
  group stm32hal
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.g4.stm32g4eval.v120.lib
  group stm32hal-config
    ../cfg/: stm32hal.startup.stm32g4eval.s
  group embot-core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot-hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_button.cpp embot_hw_tlv493d.cpp embot_hw_i2c.cpp embot_hw_i2ce.cpp
  group embot-os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group osal
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot-app
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::bsp
    ../../../bsp/: embot_hw_bsp_stm32g4eval.cpp embot_hw_button_bsp_stm32g4eval.cpp embot_hw_can_bsp_stm32g4eval.cpp embot_hw_flash_bsp_stm32g4eval.cpp embot_hw_gpio_bsp_stm32g4eval.cpp embot_hw_i2c_bsp_stm32g4eval.cpp embot_hw_i2ce_bsp_stm32g4eval.cpp embot_hw_led_bsp_stm32g4eval.cpp embot_hw_specialize_bsp_stm32g4eval.cpp embot_hw_tlv493d_bsp_stm32g4eval.cpp embot_hw_bsp_DRIVER_stm32g4eval.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
target stm32g4eval-ulpro (6220000::V6.22::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: g4eval +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_STM32G4EVAL STM32HAL_DRIVER_V120
  c misc: -DEMBOT_USE_rtos_osal
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0
